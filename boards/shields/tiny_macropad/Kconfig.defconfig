## boards/shields/tiny_macropad/Kconfig.defconfig
```kconfig
if SHIELD_TINY_MACROPAD

config ZMK_KEYBOARD_NAME
    default "Mini Macro EC11"

endif
```
